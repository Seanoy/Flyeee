# Keil uVision project Flyeee.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Flyeee +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: .\USER;.\ThirdParty\fat_fs\inc;.\FWlib\inc;.\CORE;.\Communication\inc;.\Flight\inc;.\Hardware\inc;.\System\inc;.\ThirdParty\FreeRTOSV10.2.1\include;.\ThirdParty\FreeRTOSV10.2.1;.\ThirdParty\FreeRTOSV10.2.1\portable\RVDS\ARM_CM4F;.\FREERTOS_Test
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ./startup/: startup_stm32f407xx.s
  group CORE
    ./CORE/: system_stm32f4xx.c
  group FWlib
    ./FWlib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group RTOS_Test/queue
    ./FREERTOS_Test/queue/: queue_basic.c queue_rxDataformMultiSource.c queue_rxLargeData.c queue_rxDataFromMultiQueue.c queue_rxDatafromMultiQueueRealistic.c queue_createMailbox.c
  group RTOS_Test/softwaretimer
    ./FREERTOS_Test/softwaretimer/: softwaretimer_basic.c softwaretimer_timerID.c
  group USER
    ./USER/: main.c stm32f4xx_it.c circulebuffer.c sensors.c stabilizer.c
  group Communication
    ./Communication/src/: communication.c niming.c
  group Flight
    ./Flight/src/: imu.c kalman_filter.c pid.c attitude_pid.c config_param.c filter.c
  group System
    ./System/src/: bsp.c bsp_sys.c bsp_usart.c
  group Hardware
    ./Hardware/src/: bsp_myiic.c bsp_24l01.c bsp_ak8963.c bsp_mpu6500.c bsp_bmp180.c bsp_led.c bsp_motor.c bsp_spi.c bsp_timer.c bsp_watchdog.c bsp_flash.c
  group FreeRTOS
    ./ThirdParty/FreeRTOSV10.2.1/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./ThirdParty/FreeRTOSV10.2.1/portable/MemMang/: heap_4.c
    ./ThirdParty/FreeRTOSV10.2.1/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 5.3.0
